Commit message: update

File: simple_driving/resources/obstacle.urdf (robot description, URDF)
Before this commit: robot simple_box, 1 links, 0 joints
Links:
- link box_link: geometry collision box size=0.5 0.5 0.5; visual box size=0.5 0.5 0.5
